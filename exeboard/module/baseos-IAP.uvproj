# Keil uVision project baseos-IAP.uvproj, settings and files
target uCOSDemo (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: uCOSDemo +hex
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,USE_STM3210C_EVAL,
  c include: .\Source\CMSIS\CM3\CoreSupport;.\Source\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Source\FWLib\inc;.\Source\APP;.\Source\BSP;.\Source\FWLib;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./Source/APP/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_it.c stm32f10x_conf.h config.c Relay.c DICA.c Beep.c serial.c UartCmd.c AT.C sapp.c Printf.c display.c LCD.c storage.c i2c-core.c CanCmd.c tsc007.c touch.c tscalibrate.c bmp.c button.c
    ./Source/BSP/Common/: stm32_i2c_hal.c
  group FWLib
    ./Source/FWLib/src/: stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_cec.c
  group cmsis
    ./Source/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Source/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ./Source/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib
    ./lib/: 0862100000STM32F103.lib
  group font
    ./Source/font/: font.c
target SRAM (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 0860210008WDCA_Main_V_1_0 +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ./obj_iap/0860210008WDCA_Main_V_1_0.bin ./obj_iap/0860210008WDCA_Main_V_1_0.axf
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_STM3210C_EVAL,IAP,USE_USART1_STDIO,CAN_ADR_FILTER,SERIAL_DEBUG
  c include: .\Source\CMSIS\CM3\CoreSupport;.\Source\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Source\FWLib\inc;.\Source\APP;.\Source\BSP;.\Source\FWLib;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\util;.\Source\BSP\Common;.\Source\FATFS;.\Source\STM32_USB-FS-Device_Driver\inc;.\Source\HAL\USBCDC;.\Source\font;.\Source\SD_Card;.\Source\SD_Card\SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\stm32f103_md.sct
